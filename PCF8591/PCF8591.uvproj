# Keil uVision project PCF8591.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: PCF8591 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Code
  group Source Group 1
    ./: STARTUP.A51
    ./Code/: main.c global.c keyboard.c segment.c timer.c iic.c PCF8591.c
