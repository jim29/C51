# Keil uVision project OLED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Code
  group Source Group 1
    ./: STARTUP.A51
    ./Code/: main.c oled.c oled.h picture.h system.c system.h ds1302.c ds1302.h
